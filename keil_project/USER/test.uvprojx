# Keil uVision project test.uvprojx, settings and files
target test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\OBJ;..\STM32F1x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F1x_FWLib\src;..\USER;..\HARDWARE\KEY;..\HARDWARE\TIME2;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\USART2;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\FLAME;..\HARDWARE\SWITCH;..\HARDWARE\DS18B20
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group FWILIB
    ../STM32F1x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_ld.s
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TIME2/: time2.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/FLAME/: flame.c
    ../HARDWARE/SWITCH/: switch.c
    ../HARDWARE/DS18B20/: ds18b20.c
